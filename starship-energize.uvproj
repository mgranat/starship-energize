# Keil uVision project starship-energize.uvproj, settings and files
target starship-energize (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: starship-energize
  c flags: Optim=1 uC99=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Code
    ./: PWM.c startup_TM4C123.s PLL.c SysTickInts.c PLL.h SysTickInts.h Control.c
